# Keil uVision project STM32F1_Demo.uvprojx, settings and files
target DoraOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Demo +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\bsp;..\..\..\DoraOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group USER
    ../../User/: main.c include.h config.h debug.h redef.h
    ../../User/bsp/exti/: stm32f10x_it.c bsp_exti.c
    ../../User/bsp/SysTick/: bsp_SysTick.c
    ../../User/bsp/usart/: bsp_usart.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/dwt_delay/: core_delay.c
  group dos/inc
    ../../../DoraOS/include/: mem.h task.h list.h dos_def.h dos_config.h
  group dos/mem
    ../../../DoraOS/mem/: mem.c
  group dos/src
    ../../../DoraOS/src/: task.c list.c
  group dos/cpu
    ../../../DoraOS/cpu/cortex-m3/: cpu.c port.c
