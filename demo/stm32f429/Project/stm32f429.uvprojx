# Keil uVision project stm32f429.uvprojx, settings and files
target stm32f429 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YH-F429 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO
  c misc: --c99
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\usart;..\User\led;..\User\config;..\..\..\include;..\..\..\include\mem;..\..\..\include\port;..\..\..\include\port\arm\cortex-m4;..\..\..\include\common\salof;..\..\..\common\lwip\include;..\..\..\common\lwip\include\compat;..\..\..\common\lwip\include\lwip;..\..\..\common\lwip\include\netif;..\..\..\common\lwip\include\lwip\apps;..\..\..\common\lwip\include\lwip\priv;..\..\..\common\lwip\include\lwip\port;..\..\..\common\lwip\arch;..\..\..\common\lwip\config;..\..\..\common\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DOC
    ../Doc/: readme.txt
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
  group USER
    ../User/: main.c stm32f4xx_it.c board.c client.c app_lwip.c
    ../User/usart/: bsp_debug_usart.c
    ../User/led/: bsp_led.c
    ../User/eth/: bsp_eth.c
  group dos/inc
    ../../../include/mem/: mem.h memp.h
    ../../../include/port/cmsis/: arm_cmsis.h
    ../../../include/: event.h list.h log.h mutex.h queue.h sem.h swtmr.h sys.h task.h
    ../User/config/: debug.h dos_config.h dos_def.h
  group dos/mem
    ../../../mem/: mem.c memp.c
  group dos/src
    ../../../src/: event.c list.c log.c mutex.c queue.c sem.c swtmr.c sys.c task.c
  group dos/port
    ../../../port/arm/cortex-m4/: port.c port.s
  group dos/common
    ../../../common/salof/: fifo.c format.c salof.c
  group dos/example
    ../../../example/: app_event.c app_mem.c app_memp.c app_mutex.c app_queue.c app_sem.c app_swtmr.c
  group lwip/api
    ../../../common/lwip/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../../../common/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../common/lwip/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/netif
    ../../../common/lwip/netif/: ethernet.c
  group lwip/arch
    ../../../common/lwip/arch/: ethernetif.c sys_arch.c
